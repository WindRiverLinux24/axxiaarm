require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm = "v5.15/standard/preempt-rt/sdkv5.10/axxia"
KBRANCH:axxiaarm64 = "v5.15/standard/preempt-rt/sdkv5.10/axxia"
