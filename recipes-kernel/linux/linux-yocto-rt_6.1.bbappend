require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm = "v6.1/standard/preempt-rt/sdkv5.10/axxia"
KBRANCH:axxiaarm64 = "v6.1/standard/preempt-rt/sdkv5.10/axxia"
