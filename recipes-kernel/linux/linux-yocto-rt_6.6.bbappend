require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm = "v6.6/standard/preempt-rt/sdkv5.15/axxia"
KBRANCH:axxiaarm64 = "v6.6/standard/preempt-rt/sdkv5.15/axxia"
