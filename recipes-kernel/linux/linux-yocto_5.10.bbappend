require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm64 = "v5.10/standard/sdkv5.10/axxia"
KBRANCH:axxiaarm = "v5.10/standard/sdkv5.10/axxia"
