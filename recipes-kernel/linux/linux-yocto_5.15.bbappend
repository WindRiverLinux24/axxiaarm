require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm64 = "v5.15/standard/sdkv5.10/axxia"
KBRANCH:axxiaarm = "v5.15/standard/sdkv5.10/axxia"
