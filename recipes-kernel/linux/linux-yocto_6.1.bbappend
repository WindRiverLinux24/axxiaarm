require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm64 = "v6.1/standard/sdkv5.10/axxia"
KBRANCH:axxiaarm = "v6.1/standard/sdkv5.10/axxia"
