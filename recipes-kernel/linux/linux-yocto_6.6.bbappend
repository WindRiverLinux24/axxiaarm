require linux-yocto-axxiaarm.inc

KBRANCH:axxiaarm64 = "v6.6/standard/sdkv5.15/axxia"
KBRANCH:axxiaarm = "v6.6/standard/sdkv5.15/axxia"
